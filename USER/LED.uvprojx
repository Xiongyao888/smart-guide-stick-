# Keil uVision project LED.uvprojx, settings and files
target SmartHome (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\OLED;..\NET\device;..\NET\MQTT;..\NET\onenet;..\HARDWARE\BEEP;..\HARDWARE\DHT11;..\SYSTEM\TIMER;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\BH1750;..\NET\cJSON;..\HARDWARE\JQ8400;..\HARDWARE\HONGWAI;..\HARDWARE\WAVE;..\HARDWARE\GY521
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/BH1750/: bh1750.c
    ../HARDWARE/HONGWAI/: HW.c
    ../HARDWARE/JQ8400/: jq8400.c
    ../HARDWARE/WAVE/: wave.c
    ../HARDWARE/GY521/: MPU6050.c MyI2C.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/TIMER/: timer.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_i2c.c
  group NET
    ../NET/device/: esp8266.c
    ../NET/MQTT/: MqttKit.c
    ../NET/onenet/: onenet.c
    ../NET/cJSON/: cJSON.c
